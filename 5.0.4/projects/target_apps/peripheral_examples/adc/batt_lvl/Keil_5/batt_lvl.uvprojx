# Keil uVision project batt_lvl.uvprojx, settings and files
target batt_lvl (5060020::V5.06 (build 20)::ARMCC)
  device: DA14583 Dialog Semiconductor
  pack: DialogSemiconductor.DA1458x_DFP.1.0.13
  cpu: CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: batt_lvl +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c misc: --thumb -c
  c include: ..\include;..\..\..\..\..\..\sdk\platform\arch;..\..\..\..\..\..\sdk\platform\arch\compiler\rvds;..\..\..\..\..\..\sdk\platform\arch\ll\rvds;..\..\..\..\..\..\sdk\platform\driver\reg;..\..\..\..\..\..\sdk\platform\include;..\..\..\..\..\..\sdk\platform\driver\gpio;..\..\..\..\..\..\sdk\platform\driver\adc;..\..\..\..\..\..\sdk\platform\driver\battery;..\..\..\..\..\..\sdk\app_modules\api;..\..\..\..\..\..\sdk\ble_stack\rwble_hl\rwble_hl;..\..\..\shared\common_uart;..\..\..\..\..\..\sdk\platform\driver\uart;..\..\..\..\..\..\sdk\platform\driver\pwm
  library: MicroLIB
  scatter file: ..\..\..\shared\peripheral_examples.sct
  group boot
    ../../../shared/startup/: boot_vectors.s system_ARMCM0.c per_ex_hard_fault.c
  group driver
    ../../../../../../sdk/platform/driver/gpio/: gpio.c
    ../../../../../../sdk/platform/driver/battery/: battery.c
    ../../../../../../sdk/platform/driver/adc/: adc.c
    ../../../../../../sdk/platform/driver/uart/: uart2.c
    ../../../../../../sdk/platform/driver/pwm/: pwm.c
  group common_uart
    ../../../shared/common_uart/: common_uart.c
  group app
    ../src/: main.c user_periph_setup.c
